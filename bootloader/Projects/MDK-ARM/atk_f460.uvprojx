# Keil uVision project atk_f460.uvprojx, settings and files
target bootloader (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F470VG GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.5.0
  cpu: IRAM(0x20000000,0x070000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x0100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: atk_f460 +hex
  AfterMake: ..\..\HexBin.bat "$K" "!L" "@L" "$L"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,GD32F470
  c include: ..\..\Drivers;..\..\User;..\..\Drivers\CMSIS;..\..\Drivers\CMSIS\GD\GD32F4xx\Include;..\..\Drivers\GD32F4xx_standard_peripheral\Include;..\..\Hardware\inc;..\..\INCLUDE;..\..\Middlewares;..\..\APP
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x70000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Startup
    ../../Drivers/CMSIS/GD/GD32F4xx/Source/ARM/: startup_gd32f450_470.s
  group User
    ../../User/: main.c gd32f4xx_it.c systick.c
    ../../Drivers/CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
  group APP
    ../../APP/TOOL/src/: crc.c
    ../../APP/UPDATE/src/: iap.c
  group Drivers/SYSTEM
    ../../Drivers/SYSTEM/sys/: sys.c
    ../../Drivers/SYSTEM/delay/: delay.c
  group Drivers/GD32F4xx_STD_Driver
    ../../Drivers/GD32F4xx_standard_peripheral/Source/: gd32f4xx_dma.c gd32f4xx_enet.c gd32f4xx_exmc.c gd32f4xx_exti.c gd32f4xx_fmc.c gd32f4xx_gpio.c gd32f4xx_i2c.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_rcu.c gd32f4xx_rtc.c gd32f4xx_sdio.c gd32f4xx_spi.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_trng.c gd32f4xx_usart.c gd32f4xx_fwdgt.c
  group Hardware
    ../../Hardware/src/: bsp_core_dwt.c bsp_led.c bsp_cpu_flash.c bsp_fwdgt.c bsp_spi_bus.c bsp_spi_flash.c bsp_timers.c bsp_key.c bsp_debug.c
  group Middlewares/malloc
    ../../Middlewares/malloc/: malloc.c
  group Readme
    ../../: readme.txt
