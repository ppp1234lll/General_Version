# Keil uVision project atk_f460.uvprojx, settings and files
target lwIP (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F470VG GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.5.0
  cpu: IRAM(0x20000000,0x070000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x0100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: atk_f460 +hex
  AfterMake: ..\..\HexBin.bat "$K" "!L" "@L" "$L"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,GD32F470
  c include: ..\..\Drivers\CMSIS\GD\GD32F4xx\Include;..\..\Drivers\GD32F4xx_standard_peripheral\Include;..\..\Drivers\CMSIS;..\..\Middlewares;..\..\Drivers;..\..\User;..\..\Middlewares\lwip\arch;..\..\Middlewares\lwip;..\..\Middlewares\lwip\src\include;..\..\Middlewares\lwip\lwip_app;..\..\Middlewares\FreeRTOS\include;..\..\Middlewares\FreeRTOS\portable\RVDS\ARM_CM4F;..\..\Include;..\..\Hardware\inc;..\..\APP;..\..\Middlewares\easybutton;..\..\Middlewares\lis3dh
  library: MicroLIB
  memory RVCT4: ROM 0x8010000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x70000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: ..\..\User\gd32-f460.sct
  group Startup
    ../../Drivers/CMSIS/GD/GD32F4xx/Source/ARM/: startup_gd32f450_470.s
  group User
    ../../User/: main.c gd32f4xx_it.c systick.c
    ../../Drivers/CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
  group App/User
    ../../APP/USER/src/: start.c save.c error.c com.c
    ../../APP/User/src/: log.c
  group APP/Task
    ../../APP/Task/src/: alarm.c dtu.c send.c
    ../../APP/TASK/src/: app.c det.c gsm.c eth.c print.c gprs_rx.c
  group APP/Update
    ../../APP/UPDATE/src/: update.c update_gsm.c update_http.c update_lwip.c
  group App/Upload
    ../../APP/Upload/src/: upload.c upload_gsm.c upload_http.c upload_lwip.c
  group APP/Driver
    ../../APP/DRIVER/src/: ATGM336H.c aht20.c BL0939_SPI.c GPRS.c
    ../../APP/Driver/src/: rs485.c BL0910_SPI.c
  group Include
    ../../Include/: appconfig.h bsp.h main.h
  group Hardware
    ../../Hardware/src/: bsp_adc.c bsp_core_dwt.c bsp_cpu_flash.c bsp_enet.c bsp_fan.c bsp_fwdgt.c bsp_hspi3.c bsp_led.c bsp_relay.c bsp_rng.c bsp_rtc.c bsp_spi_bus.c bsp_spi_flash.c bsp_timers.c bsp_usart0.c bsp_usart5.c bsp_debug.c bsp_key.c bsp_usart2.c bsp_siic.c bsp_uart3.c bsp_uart4.c bsp_uart6.c bsp_uart7.c bsp_hspi1.c bsp_hspi2.c bsp_sspi1.c bsp_sspi2.c bsp_sspi3.c bsp_usart1.c
  group Drivers/SYSTEM
    ../../Drivers/SYSTEM/sys/: sys.c
    ../../Drivers/SYSTEM/delay/: delay.c
  group Drivers/GD32F4xx_STD_Driver
    ../../Drivers/GD32F4xx_standard_peripheral/Source/: gd32f4xx_adc.c gd32f4xx_can.c gd32f4xx_crc.c gd32f4xx_ctc.c gd32f4xx_dac.c gd32f4xx_dbg.c gd32f4xx_dci.c gd32f4xx_dma.c gd32f4xx_enet.c gd32f4xx_exmc.c gd32f4xx_exti.c gd32f4xx_fmc.c gd32f4xx_fwdgt.c gd32f4xx_gpio.c gd32f4xx_i2c.c gd32f4xx_ipa.c gd32f4xx_iref.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_rcu.c gd32f4xx_rtc.c gd32f4xx_sdio.c gd32f4xx_spi.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_tli.c gd32f4xx_trng.c gd32f4xx_usart.c gd32f4xx_wwdgt.c
  group Middlewares/lis3dh
    ../../Middlewares/lis3dh/: hal_lis3dh.c lis3dh_driver.c lis3dh_iic.c lis3dh_spi.c
  group Middlewares/malloc
    ../../Middlewares/MALLOC/: malloc.c
  group Middlewares/littlefs
    ../../Middlewares/littlefs/: lfs.c lfs_port.c lfs_util.c
  group Middlewares/tool
    ../../Middlewares/tool/src/: convert.c crc.c md5.c SHA1.c
  group Middlewares/cjson
    ../../Middlewares/cjson/: cJSON.c mycJSON.c
  group Middlewares/easybutton
    ../../Middlewares/easybutton/: ebtn.c ebtn_app.c ebtn_APP_Event.c ebtn_APP_HAL.c ebtn_APP_Keys.c
  group Middlewares/lwip/src/api
    ../../Middlewares/lwip/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group Middlewares/lwip/src/core
    ../../Middlewares/lwip/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../Middlewares/lwip/src/core/ipv4/: acd.c autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group Middlewares/lwip/src/netif
    ../../Middlewares/lwip/src/netif/: ethernet.c
  group Middlewares/lwip/arch
    ../../Middlewares/lwip/arch/: ethernetif.c lwip_comm.c sys_arch.c lwipopts.h
  group Middlewares/lwip/ping
    ../../Middlewares/lwip/lwip_app/ping/: lwip_ping.c lwip_ping_multi.c lwip_ping_remote.c
  group Middlewares/lwip/tcp
    ../../Middlewares/lwip/lwip_app/tcp_client/: tcp_client.c
  group Middlewares/lwip/udp_multicast
    ../../Middlewares/lwip/lwip_app/udp_multicast/: udp_multicast.c
  group Middlewares/lwip/snmp
    ../../Middlewares/lwip/lwip_app/snmp_udp/: snmp_udp.c
  group Middlewares/lwip/onvif
    ../../Middlewares/lwip/lwip_app/onvif/: onvif.c onvif_agree.c onvif_deal.c onvif_digest.c onvif_prefixlen.c onvif_tcp.c sadp.c
  group Middlewares/lwip/port
    ../../Middlewares/lwip/lwip_app/port_scan/: port_scan.c
  group Middlewares/lwip/rtsp
    ../../Middlewares/lwip/lwip_app/rtsp_client/: rtsp.c rtsp_task.c
  group Middlewares/lwip/web
    ../../Middlewares/lwip/lwip_app/web_server/: fs.c httpd.c httpd_cgi.c httpd_cgi_ssi.c httpd_ssi.c
  group Middlewares/FreeRTOS_CORE
    ../../Middlewares/FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group Middlewares/FreeRTOS_PORT
    ../../Middlewares/FreeRTOS/portable/MemMang/: heap_4.c
    ../../Middlewares/FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
    ../../User/: FreeRTOSConfig.h
  group Readme
    ../../Doc/: 01.功能说明.txt 02.修改记录.txt 03.硬件资源.txt
